# Keil uVision project sdt.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC11C14/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: sdt +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group System
    ./: startup_LPC11xx.s system_LPC11xx.c
  group UserCode
    ./: sdt_main.c gpio.c led.c timer.c
  group Include
    ./: gpio.h led.h type.h timer.h
